# IAR project cashless.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 340
  General.GHeapSize2: 256
  General.RadioHeapSizeType: 0
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: C:\Users\Guillermo\Documents\Bingo\Olimex\cashless\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430 Generic MSP430 device
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430.xcl
  group (top)
    ./: bitmap.c card.c cashless.c cs8900.c dacom.c display.c enc28j60.c flash.c fram.c ks0108.c md5.c mgmt.c serial.c support.s43 tcpip.c
